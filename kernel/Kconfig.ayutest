## kernel/Kconfig.ayutest
```kconfig
config AYUTEST
        bool "prints hello"
        default y
        help
                This will prints hello
```
